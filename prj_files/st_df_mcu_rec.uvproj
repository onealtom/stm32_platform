# Keil uVision project st_df_mcu_rec.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CEDTMAU_MCU_V001F001R_
  AfterMake: fromelf --bin --output #L.bin #L
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\source\app;..\source\drv;..\source\drv\utility;..\source\ex_conf;..\source\lib\usb_cdc\inc;..\source\lib\CMSIS\Core\CM3;..\source\lib\STM32F10x_StdPeriph_Driver\inc;..\source\lib\SPIFFS;..\source\drv\spiflash_drv;..\source\drv\mymalloc;..\source\app\json;..\source\lib;..\source\app\fs
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Drv
    ../source/drv/: adc_drv.c global_drv.c gpio_drv.c phy_drv.c spi_drv.c stm32f10x_it.c timer_drv.c uart_drv.c usb_drv.c pl_spi_drv.c
    ../source/drv/utility/: retarget.c math.c
    ../source/drv/ad9361api/: ad936x_init_main.c ad9361.c ad9361_api.c ad9361_conv.c platform.c util.c
    ../source/drv/spiflash_drv/: spiflash_drv.c
    ../source/drv/mymalloc/: mymalloc.c
  group App
    ../source/app/: adc_app.c crc8.C fpga.c init.c main.c msg_app.c spi_app.c update_app.c usbTxRx.c param_dat.c uart_app.c
    ../source/cli/: cmd_prompt.c getopt.c
    ../source/app/json/: chn2freq.c common_hw.c confctrl.c formula.c json_parse.c port.c cJSON.c json_main.c
    ../source/app/fs/: fs.c
  group StdLib
    ../source/lib/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ../source/lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
    ../source/lib/SPIFFS/: spiffs_cache.c spiffs_check.c spiffs_gc.c spiffs_hydrogen.c spiffs_nucleus.c
    ../source/lib/: tools.c
  group Asm
    ../source/asm/: startup_stm32f10x_hd.s
  group UsbLib
    ../source/lib/usb_cdc/src/: usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_sil.c
